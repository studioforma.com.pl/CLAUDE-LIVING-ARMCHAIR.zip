Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Claude-Living Armchair - ver4.ifc
Time: 2025-11-02T23:57:45
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (4)
Name
 | Claude-Living Armchair_0 - ObjectType: SketchupGroup
 | Claude-Living Armchair_1 - ObjectType: SketchupGroup
 | Claude-Living Armchair_2 - ObjectType: SketchupGroup
 | Claude-Living Armchair_3 - ObjectType: SketchupGroup
